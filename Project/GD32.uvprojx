# Keil uVision project GD32.uvprojx, settings and files
target GD32 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,ARM_MATH_CM4,__FPU_PRESENT,__FPU_USED,__TARGET_FPU_VFP
  c include: ..\CMSIS;..\FWLIB\Include;..\FWLIB\Source;..\User;..\BSP;..\BSP\include;..\APP;..\CMSIS\DSP;..\CMSIS\lib;..\CMSIS\DSP\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CMSIS/: startup_gd32f30x_hd.s system_gd32f30x.c
    ../CMSIS/lib/: arm_cortexM4lf_math.lib
  group FWLIB
    ../FWLIB/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group User
    ../User/: main.c gd32f30x_it.c systick.c
  group BSP
    ../BSP/: bsp_gpio.c bsp_usart.c bsp_time.c bsp_spi.c bsp_adc.c bsp_can.c bsp_flash.c
  group APP
    ../APP/: foc_encoder.c foc_handle.c usr_config.c drv8323.c fsm.c led.c util.c controller.c trapTraj.c calibration.c can.c
